# IAR project SwbPjc.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 600
  General.GHeapSize2: 600
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    Src/: Communication.c main.c Rtc.c SystemCtl.c
  group ADC
    Src/: BatteryDetect.c
  group BeiDou_Module
    Src/: BeiDouModule.c Uart3.c
  group CDMA_Module
    Src/: CdmaModule.c Uart1.c
  group Debug
    Src/: DebugCmd.c Uart2.c
  group GPS_Module
    Src/: GpsParse.C Uart0.c
  group OS_MEM
    Src/: OS_MEM.C
  group Rtc&Eeprom
    Src/: I2c_Driver.c Record.c
  group TIMER
    Src/: SoftTimer.c Timer.c
